## boards/shields/dumbpad_v1_1/Kconfig.defconfig
```kconfig
if SHIELD_DUMBPAD_V1_1

config ZMK_KEYBOARD_NAME
    default "dumbpad_v1_1"

endif
```
